Commit message: add new goal

File: robot_baseline/robot/resources/redbox.urdf (robot description, URDF)
Before this commit: robot solid_sphere, 1 links, 0 joints
Links:
- link link1: geometry collision box size=0.5 0.5 0.2; visual box size=1.5 2.5 0.02
